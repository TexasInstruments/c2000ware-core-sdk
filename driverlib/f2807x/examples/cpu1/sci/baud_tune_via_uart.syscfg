/**
 * These arguments were used when this file was generated. They will be automatically applied on subsequent loads
 * via the GUI or CLI. Run CLI with '--help' for additional information on how to override these arguments.
 * @cliArgs --device "F2807x" --part "F2807x_176PTP" --package "F2807x_176PTP" --context "system"
 * @v2CliArgs --device "TMS320F2807x" --package "176PTP" --context "system"
 */

/**
 * Import the modules used in this configuration.
 */
var sci = scripting.addModule("/driverlib/sci.js", {}, false);
var sci1 = sci.addInstance();

/**
 * Write custom configuration values to the imported modules.
 */
sci1.$name = "mySCI0";
sci1.baudRates = 9600;
sci1.sci.$name = "MySCI1";
sci1.sci.scirxdPin.$assign = "GPIO9";
sci1.sci.scitxdPin.$assign = "GPIO8";